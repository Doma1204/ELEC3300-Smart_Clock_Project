# Keil uVision project Smart_Clock.uvprojx, settings and files
target Smart_Clock (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Smart_Clock +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../../../../../../../Inc;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Library/Inc;../../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../../UI/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../../../../../../../Src/: main.c gpio.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c i2c.c sdio.c spi.c sys.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../../../../../../../Src/: system_stm32f4xx.c
  group Library
    ../../../../../../../Library/Src/: button.c led.c tft.c pir.c esp8266.c epochToNormal.c xpt2046.c gy39.c file.c WS2812.c
  group Middlewares/FatFs
    ../../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group UI
    ../../../../../../../UI/Src/: weather_widget.c main_tft_screen.c UI.c RGB.c
software components: CMSIS:CORE 4.3.0
